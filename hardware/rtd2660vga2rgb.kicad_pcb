# Repository nhatsonelec-cyber/rtd2660vga2rgb (continued)

## KiCad design hardware/rtd2660vga2rgb.kicad_pcb (continued)

Board: 4 copper layers, 168 parts (91 on the bottom side), 149 nets, no tracks yet.

File docs/bom.csv:

Qty,References,Value,Footprint,Side,Note
2,C1 C2,22uF,C_0805_2012Metric,bottom,
13,C3 C4 C5 C6 C7 C8 C9 C10 C13 C39 C43 C52 C55,10uF,C_0805_2012Metric,bottom/top,
5,C11 C58 C59 C61 C62,1uF 50V,C_0805_2012Metric,bottom/top,
1,C12,220nF,C_0603_1608Metric,top,
20,C14 C29 C30 C31 C32 C34 C36 C37 C38 C40 C41 C42 C44 C45 C46 C51 C53 C54 C63 C65,100nF,C_0603_1608Metric,bottom/top,
6,C20 C21 C22 C23 C24 C25,47nF,C_0603_1608Metric,top,
1,C26,1nF,C_0603_1608Metric,top,
2,C27 C28,22pF,C_0603_1608Metric,top,
4,C33 C35 C50 C64,1uF,C_0603_1608Metric,bottom,
1,C56,10uF 25V,C_0805_2012Metric,top,
2,C57 C60,100nF 50V,C_0603_1608Metric,top,
2,D1 D2,MBR0540,D_SOD-123,top,
2,D3 D5,BAT54S,SOT-23,top,
1,D4,18V BZT52C18S,D_SOD-323,bottom,
1,D6,6.2V BZT52C6V2S,D_SOD-323,bottom,
1,D7,GREEN,LED_0603_1608Metric,top,
1,F1,1.5A PTC,Fuse_1206_3216Metric,bottom,
2,FB1 FB2,600R@100MHz,L_0603_1608Metric,bottom,
1,J1,VGA DE-15 F,DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03mm_Housed_MountingHolesOffset4.94mm,top,
1,J2,FPC-50 0.5mm,Hirose_FH12-50S-0.5SH_1x50-1MP_P0.50mm_Horizontal,bottom,
1,J3,FPC-40 0.5mm,Hirose_FH12-40S-0.5SH_1x40-1MP_P0.50mm_Horizontal,top,
1,J4,FLASH PROG,PinHeader_1x07_P1.27mm_Vertical,top,
1,J5,USB-C 5V,USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal,top,
1,J6,5V IN,PinHeader_1x02_P2.54mm_Vertical,top,
1,J7,KEYPAD,PinHeader_2x05_P1.27mm_Vertical_SMD,top,
1,JP1,MODE,SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm,bottom,
1,JP2,SHLR,SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm,bottom,
1,JP3,UPDN,SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm,bottom,
1,JP4,BL HIGH,SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,bottom,
1,JP5,DITHB,SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm,bottom,
2,L1 L2,2.2uH,L_Taiyo-Yuden_NR-30xx,bottom,
2,L3 L4,10uH,L_Taiyo-Yuden_NR-40xx,top,
1,Q1,AO3401A,SOT-23,bottom,
2,Q2 Q3,2N7002,SOT-23,bottom,
3,R1 R2 R43,5.1k,R_0603_1608Metric,bottom/top,
1,R3,453k,R_0603_1608Metric,bottom,
5,R4 R6 R32 R35 R47,100k,R_0603_1608Metric,bottom,
1,R5,200k,R_0603_1608Metric,bottom,
1,R7,5.1R 1%,R_0603_1608Metric,top,
1,R8,2.4R 1%,R_0603_1608Metric,top,
13,R9 R10 R17 R18 R26 R33 R34 R36 R38 R39 R46 R60 R63,10k,R_0603_1608Metric,bottom/top,
1,R11,1k,R_0603_1608Metric,bottom,DNP
3,R12 R13 R14,75R,R_0603_1608Metric,top,
9,R15 R16 R30 R50 R51 R52 R53 R54 R55,100R,R_0603_1608Metric,bottom/top,
3,R19 R20 R31,33R,R_0603_1608Metric,bottom/top,
6,R21 R22 R23 R27 R28 R29,4.7k,R_0603_1608Metric,bottom/top,
1,R24,27k,R_0603_1608Metric,bottom,
6,R25 R40 R41 R57 R61 R62,1k,R_0603_1608Metric,bottom,
1,R37,150k,R_0603_1608Metric,top,
1,R42,20k,R_0603_1608Metric,bottom,
1,R44,22R,R_0603_1608Metric,bottom,
1,R45,6.8k,R_0603_1608Metric,top,
1,R56,1M,R_0603_1608Metric,bottom,
1,R58,2k,R_0603_1608Metric,bottom,
1,R59,3.9k,R_0603_1608Metric,bottom,
7,RN1 RN2 RN3 RN4 RN5 RN6 RN7,33R,R_Array_Convex_4x0603,top,
1,RV1,10k,Potentiometer_Bourns_TC33X_Vertical,bottom,
1,U1,RTD2660,LQFP-128-1EP_14x20mm_P0.5mm_EP7.1x7.1mm,top,
2,U2 U3,TLV62569DBV,SOT-23-5,bottom,
1,U4,W25X40CL / W25Q80,SOIC-8_3.9x4.9mm_P1.27mm,top,
1,U5,24C16,SOIC-8_3.9x4.9mm_P1.27mm,top,
1,U6,MT3608,SOT-23-6,top,
1,U7,TPS61165DBV,SOT-23-6,top,
1,U8,LMV321,SOT-23-5,bottom,
1,Y1,27.000MHz,Crystal_SMD_3225-4Pin_3.2x2.5mm,top,
